require curl_${PV}.bb
inherit native
DEPENDS = "openssl-native zlib-native"

