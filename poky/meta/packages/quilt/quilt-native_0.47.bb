PV = "0.47"
PR = "r2"
require quilt-native.inc
SRC_URI += "file://patch.patch;patch=1"
