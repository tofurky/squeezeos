inherit pkgconfig

require openssl.inc

PR = "r0"

PARALLEL_MAKE = ""
