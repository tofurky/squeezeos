require pkgconfig.inc
inherit native
DEPENDS = ""

SRC_URI += "file://glib_new_gcc.patch;patch=1"
